options:
  parameters:
    author: Daniel Rojas
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador_de_amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente de sensibilidad AM
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '0'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/64
  states: {}
- name: CalculoPotenciacomunicaciones_0
  id: CalculoPotenciacomunicaciones
  parameters:
    I_vect: '1024'
  states: {}
- name: SSD_0
  id: SSD
  parameters:
    Ac: Ac
    Ka: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [SSD_0, '0', blocks_complex_to_real_0, '0']
- [SSD_0, '0', qtgui_freq_sink_x_0, '0']
- [SSD_0, '0', qtgui_time_sink_x_0, '0']
- [SSD_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', SSD_0, '0']
- [blocks_complex_to_real_0, '0', CalculoPotenciacomunicaciones_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
